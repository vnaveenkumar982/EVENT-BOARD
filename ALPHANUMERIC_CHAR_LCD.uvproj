# Keil uVision project ALPHANUMERIC_CHAR_LCD.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: lcd_prime +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s lcd.c lcd_defines.h delay.c lcd .h lcd_basic_time.c lcd_prime.c scroll_msg_lcd.c rotate_msg_lcd.c ascii_lcd.c lcd_binary.c convert_fl_char.c lcd_palin.c capitalize_only_fl.c lcd_rem_spaces.c
