# Keil uVision project ASG_7SEG.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: cnt_7seg +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s delay.c seven_seg_asg1.c even_odd_7seg.c seven_seg_asg3.c 7seg_asg_cnt.c 00_88_5times.c ca7seg_test1.c 7seg_prime.c
